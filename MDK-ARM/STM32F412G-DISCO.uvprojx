# Keil uVision project STM32F412G-DISCO.uvprojx, settings and files
target STM32F412G-DISCO (6240000::V6.24::ARMCLANG)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F412G-DISCO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F412Zx,USE_BPP=16
  c include: ../Application/User/Adapter/Inc;../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include;../Application/User/Adapter/RlSdk/led_driver;../Application/User/Adapter/RlSdk/minerva;../Application/User/Adapter/RlSdk/minerva/include;../Application/User/Adapter/RlSdk/minerva/generated;../Application/User/Adapter/RlSdk/minerva/src/core;../Application/User/Adapter/RlSdk/minerva/src/arch;../Application/User/Adapter/RlSdk/minerva/src/security;../Application/User/Adapter/RlSdk/minerva/src/hal
  asm include: ..\Core\Inc;../Application/User/Adapter/Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\STM32F412G-DISCO.sct
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/RlSdkPort
    ../Application/User/Adapter/RlSdk/led_driver/: rl2812_driver_stm32.c
    ../Application/User/Adapter/RlSdk/minerva/: rl_minerva.c rl_minerva_kws.c
    ../Application/User/Adapter/RlSdk/minerva/generated/: weights.c
    ../Application/User/Adapter/RlSdk/minerva/src/arch/: mnv_mlp.c
    ../Application/User/Adapter/RlSdk/minerva/src/core/: mnv_engine.c mnv_fixed.c
    ../Application/User/Adapter/RlSdk/minerva/src/security/: mnv_blake2s.c mnv_chacha20.c mnv_ct.c mnv_lut.c mnv_outauth.c
  group Application/User/Adapter
    ../Application/User/Adapter/Src/: rl_sdk_bridge.c mnv_hal_stm32.c fft_api.c diag_log.c syscalls_diag.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../TouchGFX/gui/src/animatedgraphics_screen/: AnimatedGraphicsPresenter.cpp AnimatedGraphicsView.cpp BumpMapImage.cpp
    ../TouchGFX/gui/src/chromart_screen/: ChromArtPresenter.cpp ChromArtView.cpp
    ../TouchGFX/gui/src/common/: DotIndicator.cpp
    ../TouchGFX/gui/src/containers/: CityInfo.cpp TemperatureMenuItem.cpp WeekInfo.cpp
    ../TouchGFX/gui/src/homeautomation_screen/: HomeAutomationPresenter.cpp HomeAutomationView.cpp JogWheel.cpp TemperatureScheduleMenuItem.cpp TemperatureSlider.cpp
    ../TouchGFX/gui/src/livedatadisplay_screen/: LiveDataDisplayPresenter.cpp LiveDataDisplayView.cpp
    ../TouchGFX/gui/src/menu_screen/: AnimatedGraphicsTile.cpp ChromArtTile.cpp HomeAutomationTile.cpp LiveDataDisplayTile.cpp MenuPresenter.cpp MenuView.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp fontcache.cpp generatedfont.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../TouchGFX/generated/gui_generated/src/animatedgraphics_screen/: AnimatedGraphicsViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/chromart_screen/: ChromArtViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/containers/: CityInfoBase.cpp TemperatureMenuItemBase.cpp WeekInfoBase.cpp
    ../TouchGFX/generated/gui_generated/src/homeautomation_screen/: HomeAutomationViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/livedatadisplay_screen/: LiveDataDisplayViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/menu_screen/: MenuViewBase.cpp
    ../TouchGFX/generated/fonts/src/: CompressedFontCache.cpp CompressedUnmappedFontCache.cpp Font_Asap_Regular_12_4bpp_0.cpp Font_Asap_Regular_16_4bpp_0.cpp Font_Asap_Regular_17_4bpp_0.cpp Font_Asap_Regular_32_4bpp_0.cpp Font_RobotoCondensed_Regular_12_4bpp_0.cpp Font_SourceSansPro_Regular_12_4bpp_0.cpp Font_SourceSansPro_Regular_14_4bpp_0.cpp Font_SourceSansPro_Regular_54_4bpp_0.cpp Font_SourceSansPro_Regular_78_4bpp_0.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_16_4bpp.cpp Kerning_Asap_Regular_17_4bpp.cpp Kerning_Asap_Regular_32_4bpp.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Kerning_SourceSansPro_Regular_12_4bpp.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_54_4bpp.cpp Kerning_SourceSansPro_Regular_78_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_16_4bpp.cpp Table_Asap_Regular_17_4bpp.cpp Table_Asap_Regular_32_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp Table_SourceSansPro_Regular_12_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_54_4bpp.cpp Table_SourceSansPro_Regular_78_4bpp.cpp
    ../TouchGFX/generated/images/src/AnimatedGraphics/: image_animated_graphics_back_button.cpp image_animated_graphics_back_button_pressed.cpp image_chrom_art_pressed.cpp image_chrom_art_released.cpp image_light_effect_image.cpp
    ../TouchGFX/generated/images/src/ChromArt/: image_chrom_art_background.cpp image_chrom_art_clouds.cpp image_chrom_art_off_button.cpp image_chrom_art_on_button.cpp image_chrom_art_sun.cpp image_layer_button.cpp image_layer_button_pressed.cpp image_st_logo.cpp image_touchgfx_logo.cpp
    ../TouchGFX/generated/images/src/HomeAutomation/: image_exit_button.cpp image_exit_button_pressed.cpp image_schedule_button.cpp image_schedule_button_pressed.cpp image_temperature_adjust_button.cpp image_temperature_adjust_button_pressed.cpp image_temperature_cancel_button.cpp image_temperature_cancel_button_pressed.cpp image_temperature_jogwheel.cpp image_temperature_menu_item.cpp image_temperature_menu_item_selected.cpp image_temperature_menu_top_day_night.cpp image_temperature_menu_top_extended.cpp image_temperature_ok_button.cpp image_temperature_ok_button_inactive.cpp image_temperature_ok_button_pressed.cpp image_temperature_schedule_button_selected.cpp image_temperature_schedule_menu_item.cpp image_temperature_schedule_menu_item_selected.cpp image_temperature_slider.cpp image_temperature_slider_knop.cpp
    ../TouchGFX/generated/images/src/LiveDataDisplay/: image_weather_background_1.cpp image_weather_background_2.cpp image_weather_background_3.cpp image_weather_background_ending_1.cpp image_weather_dot_normal.cpp image_weather_dot_selected.cpp image_weather_small_icon_cloud.cpp image_weather_small_icon_shower.cpp image_weather_small_icon_sun.cpp image_weather_small_icon_sun_bigcloud.cpp image_weather_small_icon_thunder.cpp
    ../TouchGFX/generated/images/src/Menu/: image_background_bottom.cpp image_background_top.cpp image_menu_item_animated_graphics.cpp image_menu_item_chrom_art.cpp
  group Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m4f/Keil6.x/: touchgfx_core_wchar16.lib
software components: CMSIS:CORE 6.1.1
